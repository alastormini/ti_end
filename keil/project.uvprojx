# Keil uVision project project.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: _MSPM0G3507_
  c include: ..\source;..\source\third_party\CMSIS\Core\Include;..\keil
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group ilb
    ../../../mspm0_sdk_2_04_00_06/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
  group user
    ../source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
    ./: empty.c empty.syscfg ti_msp_dl_config.c ti_msp_dl_config.h bsp_sg90.c bsp_sg90.h board.c board.h uart.c uart.h buzzer.c buzzer.h key.c key.h oled.c oled.h oledfont.h oled_show.c oled_show.h
